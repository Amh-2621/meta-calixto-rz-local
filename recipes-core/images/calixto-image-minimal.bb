require recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL_append=" canutils minicom i2c-tools"
